# Keil uVision project EmbedBolt316.uvprojx, settings and files
target EmbedBolt316 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EmbedBolt316 +hex
  BeforeMake: cmd.exe /C "E:\TI2026\mspm0_sdk_2_10_00_04\tools\keil\syscfg.bat 'E:\TI2026\mspm0_sdk_2_10_00_04\mspm0g3507\project\' config/EmbedBolt316.syscfg"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\config;..\..\source;..\..\tests\unit_tests;..\..\source\third_party\u8g2;..\..\source\third_party\CMSIS\Core\Include;..\..\custom_src\application\control;..\..\custom_src\core\config;..\..\custom_src\core\system;..\..\custom_src\drivers\actuators\motor;..\..\custom_src\drivers\actuators\voice_light_alert;..\..\custom_src\drivers\communication;..\..\custom_src\drivers\display\oled;..\..\custom_src\drivers\io_expander;..\..\custom_src\drivers\sensors\encoder;..\..\custom_src\drivers\sensors\gray_detect;..\..\custom_src\drivers\sensors\mpu6050;..\..\custom_src\drivers\sensors\vl53l1x;..\..\custom_src\drivers\sensors\vl53l1x\vl53l1x_platform;..\..\custom_src\drivers\sensors\wit_gyro;..\..\custom_src\hal\i2c;..\..\custom_src\hal\spi;..\..\custom_src\hal\uart;..\..\custom_src\hal\adc;..\..\custom_src\middleware\communication\lwpkt;..\..\custom_src\middleware\communication\lwrb;..\..\custom_src\middleware\communication\protocol;..\..\custom_src\middleware\ui\button;..\..\custom_src\middleware\ui\graphics;..\..\custom_src\utils;..\..\custom_src\middleware\ui;..\..\custom_src\application\task_2024h;..\..\custom_src\application\task_2022c;..\..\custom_src\application\task_2021f;..\..\custom_src\drivers\sensors\imu660ra;..\..\custom_src\middleware\fusion;..\..\custom_src\application\task_2025k;..\..\custom_src\drivers\sensors\LSM6DSV16X
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ..\config\mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Config
    ../../custom_src/core/config/: common_include.h log_config.h
  group Application/Tasks
    ../../custom_src/application/task_2025k/: task25k_config.h task25k_cam_app.c task25k_car_controller.c task25k_car_pid_parameter.c task25k_mission_table.c task25k_ui_app.c
  group Core
    ../../custom_src/core/: main.c
    ../../custom_src/core/system/: mspm0g3507_it.c periodic_event_task.c systick.c
    ../config/: ti_msp_dl_config.c EmbedBolt316.syscfg
  group HAL
    ../../custom_src/hal/i2c/: hal_soft_i2c.c
    ../../custom_src/hal/spi/: hal_spi.c
    ../../custom_src/hal/uart/: hal_uart.c
    ../../custom_src/hal/adc/: hal_adc.c
  group Drivers/Sensors
    ../../custom_src/drivers/sensors/encoder/: encoder.c encoder_user.c
    ../../custom_src/drivers/sensors/gray_detect/: gray_detection.c ganv_calibration.c no_mcu_ganv.c
    ../../custom_src/drivers/sensors/mpu6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpuiic.c
    ../../custom_src/drivers/sensors/wit_gyro/: wit_jyxx.c
    ../../custom_src/drivers/sensors/vl53l1x/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
    ../../custom_src/drivers/sensors/vl53l1x/vl53l1x_platform/: vl53l1_platform.c vl53l1_read.c
    ../../custom_src/drivers/sensors/imu660ra/: attitude_algorithm.c pose.c pose_math.c zf_device_imu_interface.c zf_device_imu660ra.c
    ../../custom_src/drivers/sensors/LSM6DSV16X/: lsm6dsv16x.c lsm6dsv16x_reg.c
  group Drivers/Actuators
    ../../custom_src/drivers/actuators/motor/: motor_l298n.c motor_tb6612.c motor_user.c
    ../../custom_src/drivers/actuators/voice_light_alert/: beep.c rgb_led.c voice_light_alert.c
  group Drivers/Communication
    ../../custom_src/drivers/communication/: bluetooth.c maix_cam.c
  group Drivers/Display
    ../../custom_src/drivers/display/oled/: oled_driver.c
  group Drivers/IO_Expander
    ../../custom_src/drivers/io_expander/: _74hc595.c pca9555.c
  group Middleware/Communication
    ../../custom_src/middleware/communication/lwpkt/: lwpkt.c
    ../../custom_src/middleware/communication/lwrb/: lwrb.c
    ../../custom_src/middleware/communication/protocol/: serialplot_protocol.c cam_protocol.c
  group Middleware/UI
    ../../custom_src/middleware/ui/button/: multi_button.c ui_button.c
    ../../custom_src/middleware/ui/graphics/: ui_animation.c ui_drawing.c ui_logic.c
  group Middleware/Fusion
    ../../custom_src/middleware/fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group Application/Control
    ../../custom_src/application/control/: car_debug.c car_state_machine.c pid.c
  group Utils
    ../../custom_src/utils/: delay.c log.c
  group Third_Party/U8G2
    ../../source/third_party/u8g2/csrc/: u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_polygon.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group Tests/UnitTests
    ../../tests/unit_tests/: bluetooth_test.c gray_detection_test.c motor_test.c mpu6050_dmp_test.c vl53l1_test.c wit_jyxx_test.c no_mcu_ganv_test.c maix_test.c lsm6dsv16x_test.c
  group Startup
    ../startup/: startup_mspm0g350x_uvision.s
